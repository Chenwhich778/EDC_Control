# Keil uVision project ros2car_mspm0.uvprojx, settings and files
target ros2car_mspm0 (6160000::V6.16::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ros2car_mspm0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: LWPRINTF_IGNORE_USER_OPTS
  c include: .\Core\Inc;.\Drivers;.\Drivers\CMSIS\Core\Include;.\Middlewares\FreeRTOS\include;.\Middlewares\FreeRTOS\portable\GCC\ARM_CM0
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group config
    ./config/: ros2car_mspm0.syscfg
  group core
    ./Core/Src/: main.c ti_msp_dl_config.c mspm0g3507_it.c uart.c
    ./Core/Startup/: startup_mspm0g350x_uvision.s
  group driverlib
    ./Drivers/ti/driverlib/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_i2c.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc_common.c dl_spi.c dl_timer.c dl_trng.c dl_uart.c dl_vref.c
  group freertos
    ./Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ./Middlewares/FreeRTOS/portable/GCC/ARM_CM0/: port.c
  group misc
    ./Core/Src/: cRingbuf.c lwprintf.c
  group bsp
    ./Core/Src/: oled.c oled_data.c tb6612.c
target test_bare (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: as above
  output: ros2car_mspm0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
